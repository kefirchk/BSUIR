#include <stdio.h>                                                 //подключение библиотеки

float** inputMatrixElements(int n, float **matrix)                 //функция ввода элементов массива
{
	int check;                                                     //объявление промежуточных переменных
	char symbol;
	printf("Введите элементы матрицы:\n");                         //приглашение на ввод элементов матрицы
	for (int i = 0; i < n; i++)                                    //цикл по i для ввода элементов матрицы
	{
		for (int j = 0; j < n; j++)                                //цикл по j
		{
			printf("Элемент[%d][%d]=", i + 1, j + 1);              //вывод на экран текста
			check = scanf_s("%f%c", (*(matrix + i) + j), &symbol); //ввод элемента матрицы
			if (check != 2 || symbol != '\n')                      //проверка  
			{
				rewind(stdin);                                     //чистка буфера
				printf("Ошибка! Попробуйте ещё раз.\n");           //вывод на экран текста об ошибке
				j--;                                               //возврат на ввод элемента матрицы
			}
			printf("\n");                                          //новая строка
		}
	}
	for (int i = 0; i < n; i++)                                    //цикл по i для вывода на экран матрицы
	{
		printf("\n");                                              //новая строка
		for (int j = 0; j < n; j++)                                //цикл по j для вывода матрицы
		{
			printf("%6.1f", *(*(matrix + i) + j));                 //вывод элемента матрицы
		}
	}
	printf("\n");                                                  //новая строка
	return matrix;                                                 //возвращение значения 
}