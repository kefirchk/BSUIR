#include "all_functions.h"                                            //подключение библиотеки

float** input_matrix(int* array, float **matrix)                      //функция ввода элементов массива
{
	int k = 1;
	int check; char symbol;                                           //объявление промежуточных переменных
	printf("Введите элементы матрицы(%dx%d):\n", array[0], array[1]); //приглашение на ввод элементов матрицы
	for (int i = 0; i < array[0]; i++)                                //цикл по i для ввода элементов матрицы
	{
		for (int j = 0; j < array[1]; j++)                            //цикл по j
		{
			printf("\nЭлемент[%d][%d]=", i + 1, j + 1);               //вывод на экран текста
			check = scanf_s("%f%c", (*(matrix + i) + j), &symbol);    //ввод элемента матрицы
			if ((*(*(matrix + i) + j)) / 10 > 0)
			{
				for (int del = 10; *(*(matrix + i) + j)==0; del*=10)
				{
					(*(*(matrix + i) + j)) / del;
					k++;
				}
			}
			if (check != 2 || symbol != '\n')                         //проверка на правильность ввода элемента
			{
				rewind(stdin);                                        //чистка буфера
				printf("Ошибка! Попробуйте ещё раз.\n");              //вывод на экран текста об ошибке
				j--;                                                  //возврат на ввод элемента матрицы
			}
		}
	}
	system("cls");
	puts("Введенная матрица:");
	for (int i = 0; i < array[0]; i++)                                //цикл по i для вывода на экран матрицы
	{
		printf("\n");                                                 //переход на новую строку
		for (int j = 0; j < array[1]; j++)                            //цикл для вывода матрицы
		{
			printf("%-7.1f", *(*(matrix + i) + j));                    //вывод элемента матрицы
		}
	}
	printf("\n");                                                     //переход на новую строку                                         
	return matrix;                                                    //возвращение значения
}